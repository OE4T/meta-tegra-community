BBCLASSEXTEND = "native"
LICENSE_FLAGS:class-native = ""
PACKAGECONFIG:class-native = "avcodec avfilter avformat swscale"
