# shader-slang links fast_float into its native generators.
BBCLASSEXTEND += "native nativesdk"
